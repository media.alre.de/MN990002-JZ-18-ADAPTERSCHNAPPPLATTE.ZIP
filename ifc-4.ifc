Properties of the parts of a building model (IFC4)

# File
Description: Adapterschnappplatte (Regler ist abnehmbar) für Berlin 3000 Gehäuse (Funk), ViewDefinition[CoordinationView]
File name: ifc-4.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: MN990002, Adapterschnappplatte (Regler ist abnehmbar) für Berlin 3000 Gehäuse (Funk)
In: Raum
Description: Optionale Adapterschnappplatte für Funk-Raumtemperatursensor FTRFBu mit universellem Lochbild zur Montage. Die Verwendung des Adapters wird empfohlen, da das Gerät dadurch abnehmbar wird und somit einen einfacheren Batteriewechel ermöglicht.; Classification: EC001231 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: MN990002; ModelLabel: JZ-18; GlobalTradeItemNumber: 4050528051677; ProductURL: https://alre.de/produkt_MN990002
Pset_Specification - NominalLength: 0.1053 m; NominalWidth: 0.1046 m; NominalDepth: 0.0045 m; NetWeight: 0.03
Pset_ALRE_ETIM_Properties - Ausführung: Montagehilfe; Länge: 104.6; ETIM-Klasse: EC001231; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-MN990002.pdf
